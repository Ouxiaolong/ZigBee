# Keil uVision project cc2530.uvproj, settings and files
target cc2530 (MCS-51)
  device: CC2530F256 Texas Instruments
  cpu: IRAM(0-0xFF) XRAM(0x0000-0x1EFF) IROM(0-0x3FFFF) CLOCK(16000000) MODC2
  output: cc2530 +hex
  c flags: Optimize=8 SizeSpeed=1
  group START
    ./: STARTUP.A51
  group USER
    ./: main.c
